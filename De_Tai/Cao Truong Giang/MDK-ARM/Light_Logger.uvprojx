# Keil uVision project Light_Logger.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Light_Logger +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\USER;..\HARDWARE\ADC_DMA;..\HARDWARE\FLASH_LOGGER;..\HARDWARE\LED7;..\HARDWARE\TIMER;..\HARDWARE\UART_INFO
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c
  group HARDWARE
    ../HARDWARE/ADC_DMA/: adc_dma.c
    ../HARDWARE/FLASH_LOGGER/: flash_logger.c
    ../HARDWARE/LED7/: led7.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/UART_INFO/: uart_info.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
